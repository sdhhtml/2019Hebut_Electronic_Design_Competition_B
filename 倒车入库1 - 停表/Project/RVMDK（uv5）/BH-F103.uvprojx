# Keil uVision project BH-F103.uvprojx, settings and files
target 按键-EXTI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,MPU9250,EMPL_TARGET_STM32F4,EMPL
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\DMP;..\..\DMP\driver\eMPL;..\..\DMP\driver\include;..\..\DMP\driver\stm32L;..\..\DMP\eMPL-hal;..\..\DMP\mllite;..\..\DMP\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h bsp_SysTick.c bsp_SysTick.h bsp_usart.c bsp_usart.h bsp_usart3.c bsp_usart3.h key.c key.h led.c led.h TIM1.c TIM1.h TIM2.c TIM2.h TIM3.c TIM3.h TIM4.c TIM4.h TIM6.c TIM6.h TIM8.c TIM8.h oled.c oled.h oledfont.h filter.c filter.h iic.c iic.h imu.c imu.h mpu6050.c mpu6050.h structconfig.h hongwai.c hongwai.h uart4.c uart4.h mpu9250.c mpu9250.h DataScope_DP.C DataScope_DP.h 函数调用示例.txt HMC5983.h HMC5983.c hmciic.c hmciic.h 1iic.c 1iic.h uart5.c uart5.h encoder.c encoder.h motor.c motor.h TIM7.c TIM7.h steer.c steer.h new_struct.c new_struct.h openmv.c openmv.h
  group eMPL
    ../../DMP/: ALIENTEK.c ALIENTEK.h
    ../../DMP/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ../../DMP/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
    ../../DMP/driver/stm32L/: log_stm32.c packet.h
    ../../DMP/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
    ../../DMP/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
    ../../DMP/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.lib mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
